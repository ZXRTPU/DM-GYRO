# Keil uVision project NB.uvprojx, settings and files
target NB (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F446RCTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x803FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: NB +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F446xx,ARM_MATH_CM4,__TARGET_FPU_VFP,__CC_ARM,__FPU_PRESENT
  c include: ..\Inc;..\Src;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Middlewares/ST/ARM/DSP/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\Drivers\CMSIS\DSP\Include;..\bsp;..\User\Algorithm;..\User\Daemon;..\User\DM_BMI088;..\User\Judge_system;..\User\miniPC;..\User\RC_device;..\User\VideoTransmitter;..\EKF;..\RTOS_TASK
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f446xx.s
  group Application/User
    ../Src/: can.c dma.c freertos.c gpio.c main.c spi.c stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c tim.c usart.c usb_device.c usbd_cdc_if.c usbd_conf.c usbd_desc.c
  group Inc
    ../Inc/: can.h dma.h FreeRTOSConfig.h gpio.h main.h spi.h stm32f4xx_hal_conf.h stm32f4xx_it.h tim.h usart.h usb_device.h usbd_cdc_if.h usbd_conf.h usbd_desc.h
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Include/: system_stm32f4xx.h
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Middlewares/Library/DSP Library/DSP Library
    ../Middlewares/ST/ARM/DSP/Lib/: arm_cortexM4l_math.lib
  group Bsp
    ../bsp/: bsp_dwt.c bsp_dwt.h bsp_usart.c bsp_usart.h drv_can.c drv_can.h drv_usart.c drv_usart.h bsp_usb.h bsp_usb.c
  group EKF
    ../EKF/: arm_math.h imuekf.c imuekf.h imuekf_data.h imuekf_initialize.c imuekf_initialize.h imuekf_terminate.c imuekf_terminate.h imuekf_types.h MW_target_hardware_resources.h rt_defines.h rt_nonfinite.c rt_nonfinite.h rtGetInf.c rtGetInf.h rtGetNaN.c rtGetNaN.h rtwtypes.h
  group User/Algorithm
    ../User/Algorithm/: CRC.c CRC.h pid.c pid.h
  group User/DM_BMI088
    ../User/DM_BMI088/: BMI088driver.c BMI088driver.h BMI088Middleware.c BMI088Middleware.h BMI088reg.h bsp_imu_pwm.c bsp_imu_pwm.h JY901.c JY901.h led_task.c led_task.h imu_task.c imu_task.h imu_temp_control_task.c imu_temp_control_task.h
  group User/Daemon
    ../User/Daemon/: Daemon.h Daemon.c
  group User/Judge_system
    ../User/Judge_system/: crc_ref.c crc_ref.h judge.c judge.h referee_protocol.h referee_task.c referee_task.h referee_UI.c referee_UI.h rm_referee.c rm_referee.h
  group User/miniPC
    ../User/miniPC/: miniPC_process.h miniPC_process.c
  group User/RC_device
    ../User/RC_device/: rc_potocal.c rc_potocal.h remote_control.h remote_control.c
  group User/VideoTransmitter
    ../User/VideoTransmitter/: VideoTransmitter.c VideoTransmitter.h
  group RTOS_TASK
    ../RTOS_TASK/: Chassis_task.c Chassis_task.h exchange.c exchange.h robot_def.h struct_typedef.h super cap.c super_cap.h UI_task.c UI_task.h
software components: CMSIS:CORE 4.3.0
